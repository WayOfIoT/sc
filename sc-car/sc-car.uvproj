# Keil uVision project sc-car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: sc-car +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: blueteeth.c delay.c motor.c sc.c steer.c timer.c sc_init.c led.c
  group Head
    ./: blueteeth.h delay.h motor.h sc.h steer.h timer.h sc_init.h led.h

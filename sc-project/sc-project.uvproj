# Keil uVision project sc-project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: sc-project +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: blueteeth.c sc.c delay.c timer.c steer.c motor.c
  group head
    ./: blueteeth.h sc.h delay.h timer.h steer.h motor.h
